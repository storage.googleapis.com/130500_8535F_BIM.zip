Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-08-10T06:10:03
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Aug 10 06:10:03 2018 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{DA8BA5F9-5196-4FC4-9F5C-790D4CCD9CE7}\ifc * Database version: 5507 * Database creation date: Fri Aug 10 06:10:02 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Aug 10 06:10:02 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Aug 10 06:10:02 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 8535F Kitchen faucet with dishwasher valve, 8535F:8535F Kitchen faucet with dishwasher valve:363114
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - InletConnectionSize: 16 mm; NominalDepth: 243 mm; NominalHeight: 349 mm; NominalWidth: 116 mm; Projection: 200 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 8535F; ConvergoRefNr: 0087-1809-0053-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_45; Uniclass2015Description: Sink manual water supply sets; Uniclass2015Reference: Pr_40_20_87_82; Version: 1; VersionDate: 09/08/2018
Type - Green Building Properties(Type) - EAN Number: 6414150051401; EN Standard: EN 817; Noise Class: II (ISO 3822) Oras lab.; NRF Number: 4200332; RSK Number: 8347964
Type - Identity Data(Type) - Class: Single lever; Group: Kitchen faucets; Manufacturer: Oras; Market: INT;EST;LVA;LTU;NOR;POL;RUS;SWE;UKR; Model: 8535F Kitchen faucet with dishwasher valve; Name_en: 8535F Kitchen faucet with dishwasher valve; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 8535F; Product Datasheet: https://www.oras.com/datasheet/8535F/en; Product Family: LA CUCINA ALESSI by Oras; Product URL: https://www.oras.com/en/products/oras/product/8535F; Type Name: 8535F Kitchen faucet with dishwasher valve
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Aerator: CACHÉ® integrated aerator; Connection Size: G3/8; Dishwasher Valve: Dishwasher valve; Flow Rate At 300kPa: 0.00741608 m3/s; Installation and Maintenance: https://www.oras.com/fileadmin/resources/110213_PDM_945448_8_(945448-04-14).pdf; Installation Type: Deck mounted; Max. Hot Water Supply: 80 kg/K/s3; Mounting Holes: 1 mounting hole; Pipes: Flexible inlet pipe(s); Pressure Loss With Flow 02ls: 280000 Pa; Spare Parts: https://www.oras.com/en/products/oras/spareparts/SP8535/; Spout Type: Swivel spout
Type - Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 8535F; Features: Single lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 8535F; Name: 8535F Kitchen faucet with dishwasher valve; ReplacementCost: n/a; Shape: Sculptured; Size: 116x243x350 mm; SustainabilityPerformance: n/a; WarrantyDescription: https://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 8535F; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 8535F Kitchen faucet with dishwasher valve
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.155389 m2; Volume: 0.00984968 m3
Identity Data - Mark: 23
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 8535F: 8535F Kitchen faucet with dishwasher valve; Family and Type: 8535F: 8535F Kitchen faucet with dishwasher valve; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 8535F: 8535F Kitchen faucet with dishwasher valve; Type Id: 8535F: 8535F Kitchen faucet with dishwasher valve; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
